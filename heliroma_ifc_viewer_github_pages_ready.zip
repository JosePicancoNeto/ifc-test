Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: c6f4d360-4723-4dbd-84ea-f3f8726aad1b, VersionGUID: b1d5dbba-f71e-4abd-8a2d-def7ff5dbe94, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordenadas compartilhadas], ExchangeRequirement [Architecture]
File name: Projeto_Objeto3D_Chat.ifc
Time: 2026-01-13T09:58:30+00:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 26.3.0.37 (PTB) - 26.3.0.37

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -47, 0, -959472; RefLongitude: -47, -52, -49, -802856; RefElevation: 0 mm
Pset_SiteCommon - Reference: Informações do projeto

# IfcBuilding
Pset_BuildingCommon - Reference: Informações do projeto; NumberOfStoreys: 2

# IfcBuildingStorey (2)
Pset_BuildingStoreyCommon - Reference: Cabeça de 8 mm
Name | LongName | Elevation (mm)
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcBuildingElementProxy (2)
In: Nível 1
Pset_BuildingElementProxyCommon - Reference: Linhas do modelo; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: Linhas do modelo
Name (Linhas do modelo:...)
327481
327482

# IfcDistributionPort (22)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name | SystemType | Group
Port_327461_1
Port_327463_1
Port_327465_3
Port_327467_3
Port_327469_3
Port_327471_0 | HEATING | Suministro hidrónico 1
Port_327471_1 | HEATING | Suministro hidrónico 1
Port_327473_0 | HEATING | Suministro hidrónico 2
Port_327473_1 | HEATING | Suministro hidrónico 2
Port_327475_0 | HEATING | Suministro hidrónico 3
Port_327475_1 | HEATING | Suministro hidrónico 3
Port_327477_3
Port_327479_0 | HEATING | Suministro hidrónico 4
Port_327479_1 | HEATING | Suministro hidrónico 4
Port_327483_0 | HEATING | Suministro hidrónico 5
Port_327483_1 | HEATING | Suministro hidrónico 5
Port_327485_0 | HEATING | Suministro hidrónico 6
Port_327485_1 | HEATING | Suministro hidrónico 6
Port_327487_0 | HEATING | Suministro hidrónico 7
Port_327487_1 | HEATING | Suministro hidrónico 7
Port_327489_0 | HEATING | Suministro hidrónico 8
Port_327489_1 | HEATING | Suministro hidrónico 8

# IfcDistributionSystem: Suministro hidrónico (8)
PredefinedType: HEATING
Pset_DistributionSystemCommon - Reference: Suministro hidrónico
Name
Suministro hidrónico 1
Suministro hidrónico 2
Suministro hidrónico 3
Suministro hidrónico 4
Suministro hidrónico 5
Suministro hidrónico 6
Suministro hidrónico 7
Suministro hidrónico 8

# IfcPipeFitting: HELIROMA_PP-RFittings_PP-R_EndCap_P-2420XXX:End Cap PP-R_P-2420XXX (2)
In: Nível 1
Type - Material: PP-R Heliroma
Type - Pset_ManufacturerTypeInformation - ModelReference: Helisystem; Manufacturer: Heliroma
Pset_EnvironmentalImpactIndicators - Reference: P-2420160; sets with these values: 2
Qto_PipeFittingBaseQuantities - Length: 73.2 mm; GrossCrossSectionArea: 0.0201035 m2; NetCrossSectionArea: 0.0201035 m2; OuterSurfaceArea: 0.0367943 m2
Name (HELIROMA_PP-RFittings_PP-R_EndCap_P-2420XXX:End Cap PP-R_P-2420XXX:...)
327461
327463

# IfcPipeFitting: HELIROMA_PP-RFittings_PP-R_WeldInSaddle_P-480XXX:Weld in Saddle PP-R_P-480XXX (4)
In: Nível 1
Type - Material: PP-R Heliroma
Type - Pset_ManufacturerTypeInformation - ModelReference: Helisystem; Manufacturer: Heliroma
Pset_EnvironmentalImpactIndicators - Reference: P-480126; sets with these values: 2
Name (HELIROMA_PP-RFittings_PP-R_WeldInSaddle_P-480XXX:Weld in Saddle PP-R_P-480XXX:...)
327465
327467
327469
327477

# IfcPipeSegment: Tipos de tubos:ROMAFASER CT Pipe SDR11 S5 P-160XXX-FCT (8)
In: Nível 1
Type - Pset_ManufacturerTypeInformation - ModelReference: ROMAFASER CT PIPE; Manufacturer: Heliroma
Pset_EnvironmentalImpactIndicators - Reference: ROMAFASER CT Pipe SDR11 S5 P-160XXX-FCT; sets with these values: 2
Name (Tipos de tubos:ROMAFASER CT Pipe SDR11 S5 P-160XXX-FCT:...) | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Group
327471 | 160.014 | 0.0044172 | 0.0377025 | Suministro hidrónico 1
327473 | 160.014 | 0.0044172 | 0.0377025 | Suministro hidrónico 2
327475 | 160.014 | 0.0044172 | 0.0377025 | Suministro hidrónico 3
327479 | 160.014 | 0.0044172 | 0.0377025 | Suministro hidrónico 4
327483 | 700 | 0.0201032 | 0.351858 | Suministro hidrónico 5
327485 | 700 | 0.0201032 | 0.351858 | Suministro hidrónico 6
327487 | 700 | 0.0201032 | 0.351858 | Suministro hidrónico 7
327489 | 526.035 | 0.0201032 | 0.264414 | Suministro hidrónico 8
